FILESEXTRAPATHS_prepend_rpi := "${THISDIR}/nyx-conf:"

