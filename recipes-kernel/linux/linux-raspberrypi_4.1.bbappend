FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://001-luneos-logo.patch \
    "

