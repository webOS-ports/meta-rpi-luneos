RDEPENDS_${PN}_remove_rpi = "sdl2-opengles-test"
