FILESEXTRAPATHS_append := "${THISDIR}/${PN}:"
SRC_URI += " \
    file://maliit-env.conf \
"
