PACKAGECONFIG:append:rpi = " hls"
