PACKAGECONFIG += "gstreamer"
