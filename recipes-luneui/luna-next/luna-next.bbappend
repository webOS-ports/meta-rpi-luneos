CXXFLAGS:append:rpi = " -I${STAGING_DIR_TARGET}/usr/include/interface/vcos/pthreads"
