# Include modules in rootfs
IMAGE_INSTALL_append_rpi = " \
	kernel-modules \
	"

