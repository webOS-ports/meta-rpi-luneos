PACKAGECONFIG_GRAPHICS:append:rpi = " kms gbm"
