# Enable only vc4 driver
GALLIUMDRIVERS:rpi = "vc4"
GALLIUMDRIVERS_LLVM:rpi = ""
